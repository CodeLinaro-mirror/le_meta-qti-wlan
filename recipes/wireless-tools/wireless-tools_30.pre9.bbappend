SRC_URI = "https://hewlettpackard.github.io/wireless-tools/wireless_tools.${PV}.tar.gz;md5sum=ca91ba7c7eff9bfff6926b1a34a4697d;sha256sum=abd9c5c98abf1fdd11892ac2f8a56737544fe101e1be27c6241a564948f34c63 \
		https://git.codelinaro.org/clo/qyocto/oss/poky/-/raw/caf_migration/yoctoproject.org/rocko/meta/recipes-connectivity/wireless-tools/wireless-tools/remove.ldconfig.call.patch?h=caf_migration/yoctoproject.org/rocko;downloadfilename=remove.ldconfig.call.patch;md5sum=20a2b6450076da2207ab128b2f52295e;sha256sum=00e8fa61e84813bf22eb85ecc50d5a5d5048e405bdd28600986b04088f6087e3 \
		https://git.codelinaro.org/clo/qyocto/oss/poky/-/raw/caf_migration/yoctoproject.org/rocko/meta/recipes-connectivity/wireless-tools/wireless-tools/man.patch?h=caf_migration/yoctoproject.org/rocko;downloadfilename=man.patch;md5sum=7baff4ff73c9b1608561a4d0cb52800d;sha256sum=26f6ec100566a1ff46accc70dc3473dbf316706554c12fdc2447651456110ed0 \
		https://git.codelinaro.org/clo/qyocto/oss/poky/-/raw/caf_migration/yoctoproject.org/rocko/meta/recipes-connectivity/wireless-tools/wireless-tools/avoid_strip.patch?h=caf_migration/yoctoproject.org/rocko;downloadfilename=avoid_strip.patch;md5sum=55d2267271332d52e3915658f3fe687d;sha256sum=bf8edf61ee556807e2333c74071e00a145743e26d089e25d0276e04e4341c2a6 \
		https://git.codelinaro.org/clo/qyocto/oss/poky/-/raw/caf_migration/yoctoproject.org/rocko/meta/recipes-connectivity/wireless-tools/wireless-tools/ldflags.patch?h=caf_migration/yoctoproject.org/rocko;downloadfilename=ldflags.patch;md5sum=fdb3d712d97d38963e3d50598c97a6b9;sha256sum=ccd8dafb90dc6bd3f32e9523a40683f622411fe5d396070938d2c8d998eb257c \
"
